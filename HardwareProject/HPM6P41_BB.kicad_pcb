# Repository Alipay1/HPM6P41_BB (continued)

## KiCad design HardwareProject/HPM6P41_BB.kicad_pcb (continued)

Parts:
C1, C2, C8, C9, C17, C18: 100nF,50V; C_0603_1608Metric
C3, C4, C5, C6, C11, C13, C14, C16: 100V 100uF; CP_Radial_D10.0mm_P5.00mm
C7, C10: 10uF,50V; C_1206_3216Metric
C12, C15: 4.7uF,50V; C_0603_1608Metric
D1, D4: LM5Z12VT1G; D_SOD-523
D2, D3, D5, D6, D7, D8, D9, D10: 1N4148WS; D_SOD-523
J1, J2, J3, J4: Conn_01x01; 48A_Connector_PCB_3
L1: VER2923; IND_VER2923_COC
Q1, Q2, Q3, Q4: HYG080N10LS1C2; TDSON-8-1
R2, R3, R10, R11: 33Ω; R_0603_1608Metric
R4, R19: 120kΩ; R_0603_1608Metric
R5, R20: 5.1kΩ; R_0603_1608Metric
R6, R7, R15, R16: 10Ω; R_0603_1608Metric
R8, R9, R13, R14: 10kΩ; R_0603_1608Metric
R12, R22, R23, R24, R25: 1mΩ 1W; R_0612_1632Metric
R17, R18, R21, R26: 100Ω; R_0603_1608Metric
R27, R28: 1kΩ; R_0603_1608Metric
TP1, TP2, TP3, TP4: TestPoint_Probe; 测试点
U1, U2: UCC27211ADRMR; DRM8_3P38X2P45_TEX
U3, U4: UCC27517; SOT-23-5

Connections:
/BB/G1: D2.2 (A), Q1.4 (G), R6.2, R8.2
/BB/G2: D3.2 (A), Q2.4 (G), R7.2, R9.2
/BB/G3: D5.2 (A), Q3.4 (G), R13.2, R15.2
/BB/G4: D6.2 (A), Q4.4 (G), R14.2, R16.2
/BB/ISENSE2+: C10.1, C11.1, C13.1, C14.1, C16.1, Q3.5 (D), R22.1, R23.1, R24.1, R25.1; also elsewhere on the board
/BB/InputVsense+: R4.2, R5.1; also elsewhere on the board
/BB/OutputVsense+: R19.2, R20.1; also elsewhere on the board
/BB/S3: C8.2, D4.2 (A), L1.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R13.1, R21.2, U2.4 (HS)
/ISENSE+: C1.2, D1.2 (A), Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), R8.1, R12.1, R17.2, U1.4 (HS); also elsewhere on the board
/ISENSE-: L1.1, R12.2; also elsewhere on the board
/PA12: R3.2, TP1.1; also elsewhere on the board
/PA13: R2.2, TP2.1; also elsewhere on the board
/PA14: R11.2, TP3.1; also elsewhere on the board
/PA15: R10.2, TP4.1; also elsewhere on the board
/PA16: U3.3 (IN+); also elsewhere on the board
/PA17: U3.4 (~IN-); also elsewhere on the board
/PA18: U4.3 (IN+); also elsewhere on the board
/PA19: U4.4 (~IN-); also elsewhere on the board
CP_S1: C1.1, D1.1 (K), R27.1, U1.2 (HB)
CP_S3: C8.1, D4.1 (K), R28.1, U2.2 (HB)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J2.1, J4.1, L1.MP (MountPin), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), R5.2, R9.1, R14.1, R20.2, U1.7 (VSS), U1.9 (EPAD), U2.7 (VSS), U2.9 (EPAD), U3.2 (GND), U4.2 (GND); also elsewhere on the board
unnamed: C17.2, R18.1
unnamed: C18.2, R26.1
unnamed: D2.1 (K), R6.1, U1.3 (HO)
unnamed: D3.1 (K), R7.1, U1.8 (LO)
unnamed: D5.1 (K), R15.1, U2.3 (HO)
unnamed: D6.1 (K), R16.1, U2.8 (LO)
unnamed: D7.2 (A), R17.1
unnamed: C17.1, D7.1 (K), D8.2 (A)
unnamed: D8.1 (K), R27.2
unnamed: D9.2 (A), R21.1
unnamed: C18.1, D9.1 (K), D10.2 (A)
unnamed: D10.1 (K), R28.2
unnamed: R3.1, U1.5 (HI)
unnamed: R2.1, U1.6 (LI)
unnamed: R11.1, U2.5 (HI)
unnamed: R10.1, U2.6 (LI)
unnamed: R18.2, U3.5 (OUT)
unnamed: R26.2, U4.5 (OUT)
VIN: C3.1, C4.1, C5.1, C6.1, C7.1, J1.1, Q1.5 (D), R4.1; also elsewhere on the board
VOUT: J3.1, R19.1, R22.2, R23.2, R24.2, R25.2; also elsewhere on the board
Vdrv: C2.1, C9.1, C12.1, C15.1, U1.1 (VDD), U2.1 (VDD), U3.1 (V_{DD}), U4.1 (V_{DD}); also elsewhere on the board

Notes on the sheet:
半桥驱动
高侧电荷泵
四开关主拓扑

Parts:
C19, C20, C21, C26, C28, C30, C41, C43: 22uF,10V; C_0603_1608Metric
C22, C29, C37: 100nF,50V; C_0603_1608Metric
C23, C24: 1uF,10V; C_0603_1608Metric
C25: 22pF; C_0603_1608Metric
C27: 4.7uF,10V; C_0603_1608Metric
C32: 100V 2.2uF; CP_Radial_D5.0mm_P2.00mm
C33, C34, C35: 10uF,25V; C_0805_2012Metric
C36: 2.2nF 50V; C_0603_1608Metric
C38: 47pF,50V; C_0603_1608Metric
C39: 1.2nF,50V; C_0603_1608Metric
C40: 75pF; R_0603_1608Metric
C42: 16V 47uF ±20%; CP_Radial_D5.0mm_P2.00mm
C88: 10nF,10V; C_0603_1608Metric
D11: DSS34; D_SOD-123F
FB1, FB2, FB3: 100Ω@100MHz 2A; L_0603_1608Metric
L2: 2.2uH; L_Changjiang_FNR252012S
L3: 0.47uH; L_Changjiang_FNR252012S
L4: 68uH,1.7A,3A; L_Chilisin_BMRB00060650
L5: 4.7uH,1.6A; L_1210_3225Metric
R29, R32, R35: 0Ω; R_0603_1608Metric
R30, R31: 1kΩ; R_0603_1608Metric
R33: 68k; R_0603_1608Metric
R34: 15k; R_0603_1608Metric
R36: 76.8k; R_0603_1608Metric
R37: 357k; R_0603_1608Metric
R38: 453k; R_0603_1608Metric
R39: 50k; R_0603_1608Metric
R40: 100k; R_0603_1608Metric
R41: 13.3k; R_0603_1608Metric
U5: SYR838; SYR838PKC; Input Voltage 5.5 V; Mpn SYR838PKC
U6: SY8089; SOT-23-5
U7: LP5907MFX-3.3; SOT-23-5
U8: REF3030; SOT-23
U9: LM5164DDA; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias
U10: TPS54302; SOT-23-6

Connections:
5V_OUT: C40.1, C41.1, C43.1, L5.2, R29.1, R32.1, R40.1
+3.3V: C25.1, C28.1, L2.1, R33.1; also elsewhere on the board
+5V: C21.1, FB2.1, R32.2, U6.1 (EN), U6.4 (IN); also elsewhere on the board
/PD24: U5.A3 (SCL); also elsewhere on the board
/PD25: U5.B1 (SDA); also elsewhere on the board
GND: C20.2, C21.2, C26.2, C28.2, C30.2, C32.2, C33.2, C34.2, C35.2, C41.2, C42.2, C43.2, R31.1, R34.2, R36.1, R39.1, R41.2, U5.B2 (GND), U5.B3 (GND), U5.B4 (AGND), U5.C1 (GND), U5.C2 (GND), U5.C3 (GND), U5.C4 (GND), U6.2 (GND), U9.1 (GND), U9.9 (EP), U10.1 (GND); also elsewhere on the board
GNDA: C19.2, C22.2, C23.2, C24.2, C27.2, C29.2, C88.2, U7.2 (GND), U8.3 (GND); also elsewhere on the board
unnamed: C20.1, R29.2, R30.1, U5.D1 (VIN), U5.D2 (VIN), U5.E1 (VIN), U5.E2 (VIN)
unnamed: C26.1, L3.1, R35.1
unnamed: C38.1, C39.2, R37.2
unnamed: D11.1 (K), FB3.1
unnamed: L3.2, U5.D3 (SW), U5.D4 (SW), U5.E3 (SW), U5.E4 (SW)
unnamed: R30.2, U5.A2 (EN)
unnamed: R31.2, U5.A1 (VSEL)
unnamed: C25.2, R33.2, R34.1, U6.5 (FB)
unnamed: L2.2, U6.3 (LX)
unnamed: C23.1, FB2.2, U7.1 (IN), U7.3 (EN)
unnamed: C19.1, C22.1, FB1.2, U8.1 (IN)
unnamed: C36.2, U9.7 (BST)
unnamed: C38.2, R38.1, R39.2, U9.5 (FB)
unnamed: R36.2, U9.4 (RON)
unnamed: C36.1, L4.1, R37.1, U9.8 (SW)
unnamed: C37.1, U10.6 (BOOT)
unnamed: C40.2, R40.2, R41.1, U10.4 (FB)
unnamed: C37.2, L5.1, U10.2 (SW)
unnamed: C33.1, C34.1, C35.1, FB3.2, U10.3 (VIN)
VANA: C24.1, FB1.1, U7.5 (OUT); also elsewhere on the board
VDD_SOC: C30.1, R35.2, U5.A4 (VOUT); also elsewhere on the board
VIN: C32.1, U9.2 (VIN), U9.3 (EN/UVLO); also elsewhere on the board
VREFH: C27.1, C29.1, C88.1, U8.2 (OUT); also elsewhere on the board
Vdrv: C39.1, C42.1, D11.2 (A), L4.2, R38.2; also elsewhere on the board

Notes on the sheet:
模拟供电&参考电压
驱动供电(12V)
3.0V
12V-5V
VDD_SOC
3.3V
5V-3.3V

Schematic: SENSE.kicad_sch, HPM6P41_BuckBoost

Parts:
C44, C47, C50, C51, C106, C109: 47pF,50V; C_0603_1608Metric
C45, C46, C48, C49, C107, C108: 100nF,50V; C_0603_1608Metric
D12, D13, D14, D15: 1N4148WS; D_SOD-523
R42, R43, R82, R83: 100Ω; R_0603_1608Metric
R44, R47, R48, R84: 33Ω; R_0603_1608Metric
TP5, TP6, TP7, TP8, TP9: TestPoint_Probe; 测试点
U11, U27: INA241A3xDDF; SOT-23-8
U12, U13: SGM8551XN; TSOT-23-5

Connections:
/BB/ISENSE2+: R83.1; also elsewhere on the board
/BB/InputVsense+: D12.2 (A), D13.1 (K), U12.3 (+); also elsewhere on the board
/BB/OutputVsense+: D14.2 (A), D15.1 (K), U13.3 (+); also elsewhere on the board
/ISENSE+: R43.1; also elsewhere on the board
/ISENSE-: R42.1; also elsewhere on the board
/PD6: C50.1, R47.2, TP9.1; also elsewhere on the board
/PD8: C109.1, R84.2, TP7.1; also elsewhere on the board
GNDA: C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C107.2, C108.2, C109.2, D13.2 (A), D15.2 (A), TP6.1, U11.2 (GND), U11.3 (REF2), U11.4 (GND), U12.2 (V-), U13.2 (V-), U27.2 (GND), U27.3 (REF2), U27.4 (GND); also elsewhere on the board
unnamed: R44.1, U11.5
unnamed: R84.1, U27.5
unnamed: C44.1, R42.2, U11.8 (+)
unnamed: C44.2, R43.2, U11.1 (-)
unnamed: R47.1, U12.1, U12.4 (-)
unnamed: R48.1, U13.1, U13.4 (-)
unnamed: C106.1, R82.2, U27.8 (+)
unnamed: C106.2, R83.2, U27.1 (-)
VANA: C45.1, C48.1, C49.1, C107.1, D12.1 (K), D14.1 (K), U11.6 (V+), U12.5 (V+), U13.5 (V+), U27.6 (V+); also elsewhere on the board
VOUT: R82.1; also elsewhere on the board
VREFH: C46.1, C108.1, U11.7 (REF1), U27.7 (REF1); also elsewhere on the board

Notes on the sheet:
此接法使得输出偏置在0.5VREF
电压采样
输入采样
电流采样
输出采样
为什么是INA241A3 带宽1.1MHz r=Vref*0.5/(I*R) r=3.0/(50*3e-1)=60
分压器参数： 120kΩ 5.1kΩ Vref：0.1V~2.9V 结果2.41V ... 72.51V

Schematic: MCU_PWR.kicad_sch, HPM6P41_BuckBoost

Parts:
C83, C86, C95, C99: 100nF,50V; C_0603_1608Metric
C84, C98, C100: 22uF,10V; C_0603_1608Metric
C85, C93, C97: 4.7uF,10V; C_0603_1608Metric
C87, C90, C91, C92, C94, C96: 100nF,10V; C_0603_1608Metric
R78, R79, R80, R81: 10K; R_0603_1608Metric
U16: HPM6P41IPB1; LQFP-100_14x14mm_P0.5mm_EP5.0x5.0mm

Connections:
+3.3V: C83.1, U16.32 (VPMC); also elsewhere on the board
/PY0: U16.33 (PY00/GPTMR3.COMP0/PWM2.P0/TRGM.P16/PGPI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); also elsewhere on the board
/PY1: U16.34 (PY01/GPTMR3.CAPT0/PWM2.P1/TRGM.P17/PGPI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); also elsewhere on the board
/PY2: U16.35 (PY02/GPTMR3.COMP1/I2C2.SCL/PWM2.P2/TRGM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); also elsewhere on the board
/PY3: U16.36 (PY03/GPTMR3.CAPT1/I2C2.SDA/MCAN0.STBY/P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); also elsewhere on the board
GND: C83.2, C87.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, R78.2, R79.2, R80.2, R81.2, U16.101 (PAD); also elsewhere on the board
GNDA: C84.2, C85.2, C86.2, U16.38 (VREFL), U16.39 (VSSA); also elsewhere on the board
unnamed: R81.1, U16.28 (DCDC_GND)
unnamed: R78.1, U16.26 (DCDC_IN)
unnamed: R79.1, U16.27 (DCDC_LP)
unnamed: R80.1, U16.31 (DCDC_SNS)
unnamed: C93.1, C95.1, U16.17 (OTPCAP)
unnamed: C97.1, C99.1, U16.37 (VPMCCAP)
VANA: C84.1, C85.1, C86.1, U16.41 (VANA); also elsewhere on the board
VDD_SOC: C87.1, C90.1, C91.1, C92.1, C94.1, C96.1, C98.1, C100.1, U16.5 (VDD_SOC), U16.11 (VDD_SOC), U16.50 (VDD_SOC), U16.68 (VDD_SOC), U16.72 (VDD_SOC), U16.84 (VDD_SOC); also elsewhere on the board
VREFH: U16.40 (VREFH); also elsewhere on the board

Notes on the sheet:
6×100nF,50V

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
Board: 4 copper layers, 100.0 x 80.3 mm, 285 parts (52 on the bottom side), 164 nets.

Other parts of the board:
BZ1-PY3: Buzzer_DummyPIn3; Buzzer_5020_MetalHole
GNDA: TestPoint_Probe; 测试点
J5-PB1, J6-PB0: SMA; SMA_Amphenol_901-144_Vertical
PA12, PA13, PA14, PA15: TestPoint_Probe; 测试点

Their connections:
/PA12: PA12.1; also elsewhere on the board
/PA13: PA13.1; also elsewhere on the board
/PA14: PA14.1; also elsewhere on the board
/PA15: PA15.1; also elsewhere on the board
GND: BZ1-PY3.3 (DUM), J5-PB1.2 (Ext), J6-PB0.2 (Ext); also elsewhere on the board
GNDA: GNDA.1; also elsewhere on the board
unnamed 103: BZ1-PY3.1 (+); also elsewhere on the board
unnamed 104: BZ1-PY3.2 (-); also elsewhere on the board
unnamed 124: J5-PB1.1 (In); also elsewhere on the board
unnamed 125: J6-PB0.1 (In); also elsewhere on the board
