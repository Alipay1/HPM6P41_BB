# Repository Alipay1/HPM6P41_BB

File README.md:

# HPM6P41四开关电源开发板

目前项目处于暂停状态，作者正在考研，非常抱歉！
您可以拉取项目的Rev3最终版本提交，这个版本可以通过测试用例，能够基本满足开发板的运行要求（ADC部分有噪声）
Rev4将在项目恢复更新后继续完善

# 测试用例

测试用例尚未完全整理，但已经可以运行

需要使用sdk_gui工具选择board与app生成您的测试用例SES工程

## KiCad design HardwareProject/HPM6P41_BB.kicad_pcb

Parts:
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
R1: 0Ω; R_0603_1608Metric

Connections:
GND: H3.1, H4.1, R1.2; also elsewhere on the board
GNDA: R1.1; also elsewhere on the board
VIN: H1.1; also elsewhere on the board
VOUT: H2.1; also elsewhere on the board

Notes on the sheet:
44QB
https://tools.hpmicro.com/pinmux
HPM PinMuxTool

Parts:
C103, C104: 100nF,50V; C_0603_1608Metric
U16: HPM6P41IPB1; LQFP-100_14x14mm_P0.5mm_EP5.0x5.0mm

Connections:
+3.3V: C103.1, C104.1, U16.79 (VIO_B01), U16.94 (VIO_B01); also elsewhere on the board
/PB0: U16.100 (PB00/GPTMR2.COMP0/XPI0.CA_SCLK/PWM0.P0/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); also elsewhere on the board
/PB1: U16.99 (PB01/GPTMR2.CAPT0/XPI0.CA_D0/PWM0.P1/TR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); also elsewhere on the board
/PB2: U16.98 (PB02/GPTMR2.COMP1/I2C2.SCL/XPI0.CA_D1/P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)
/PB3: U16.97 (PB03/GPTMR2.CAPT1/I2C2.SDA/SPI0.CS3/MCA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); also elsewhere on the board
/PB4: U16.96 (PB04/UART1.CTS/SPI0.SCLK/MCAN0.RXD/XPI0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); also elsewhere on the board
/PB5: U16.95 (PB05/GPTMR2.COMP2/UART1.DE/UART1.RTS/SP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)
/PB12: U16.93 (PB12/UART3.CTS/I2C1.SDA/SPI0.MISO/XPI0.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)
/PB13: U16.92 (PB13/GPTMR2.COMP3/UART3.DE/UART3.RTS/I2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); also elsewhere on the board
/PB14: U16.91 (PB14/UART3.RXD/SPI0.DAT2/MCAN1.RXD/XPI0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); also elsewhere on the board
/PB15: U16.90 (PB15/GPTMR0.COMP3/UART3.TXD/SPI0.DAT3/M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); also elsewhere on the board
/PB16: U16.89 (PB16/GPTMR3.COMP0/XPI0.CB_D0/PWM2.P0/TR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)
/PB17: U16.88 (PB17/GPTMR3.CAPT0/XPI0.CB_D1/PWM2.P1/TR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)
/PB18: U16.87 (PB18/GPTMR3.COMP1/I2C2.SCL/XPI0.CB_D2/P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)
/PB19: U16.86 (PB19/GPTMR3.CAPT1/I2C2.SDA/SPI2.CS3/MCA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)
/PB20: U16.85 (PB20/UART0.CTS/MCAN0.RXD/PWM2.P4/TRGM.P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)
/PC12: U16.83 (PC12/I2C1.SDA/SPI1.MISO/PWM1.P4/TRGM.P1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)
/PC13: U16.82 (PC13/GPTMR1.COMP3/I2C1.SCL/SPI1.MOSI/MC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); also elsewhere on the board
/PC14: U16.81 (PC14/SPI1.DAT2/MCAN1.RXD/PWM1.P6/TRGM.P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)
/PC15: U16.80 (PC15/GPTMR0.COMP3/SPI1.DAT3/MCAN1.TXD/P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)
/PC16: U16.78 (PC16/GPTMR3.COMP0/PWM2.P0/TRGM.P16/ETH0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)
/PC17: U16.77 (PC17/GPTMR3.CAPT0/PWM2.P1/TRGM.P17/ETH0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)
/PC18: U16.76 (PC18/GPTMR3.COMP1/I2C2.SCL/PWM2.P2/TRGM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)
/PC19: U16.75 (PC19/GPTMR3.CAPT1/I2C2.SDA/MCAN0.STBY/P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)
/PC20: U16.74 (PC20/SPI2.SCLK/MCAN0.RXD/PWM2.P4/TRGM.P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)
/PC21: U16.73 (PC21/GPTMR3.COMP2/SPI2.CS0/MCAN0.TXD/PW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)
GND: C103.2, C104.2; also elsewhere on the board

Parts:
C101, C102: 100nF,50V; C_0603_1608Metric
U16: HPM6P41IPB1; LQFP-100_14x14mm_P0.5mm_EP5.0x5.0mm
U26: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm

Connections:
+3.3V: C101.1, C102.1, U16.10 (VIO_B00), U16.16 (VIO_B00); also elsewhere on the board
/J_TCK: U16.13 (PA06/GPTMR0.CAPT0/UART1.RXD/SPI1.MISO/P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), U26.4 (D2+), U26.7 (NC); also elsewhere on the board
/J_TDI: U16.14 (PA05/GPTMR1.COMP2/UART1.DE/UART1.RTS/SP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), U26.2 (D1-), U26.9 (NC); also elsewhere on the board
/J_TDO: U16.15 (PA04/UART1.CTS/SPI1.SCLK/MCAN0.RXD/PWM0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), U26.1 (D1+), U26.10 (NC); also elsewhere on the board
/J_TMS: U16.12 (PA07/GPTMR0.COMP0/UART1.TXD/SPI1.MOSI/P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), U26.5 (D2-), U26.6 (NC); also elsewhere on the board
/PA0: U16.25 (PA00/GPTMR1.COMP0/UART0.TXD/PWM0.P0/TRG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); also elsewhere on the board
/PA1: U16.24 (PA01/GPTMR1.CAPT0/UART0.RXD/PWM0.P1/TRG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); also elsewhere on the board
/PA2: U16.23 (PA02/GPTMR1.COMP1/UART0.DE/UART0.RTS/I2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); also elsewhere on the board
/PA3: U16.22 (PA03/GPTMR1.CAPT1/UART0.CTS/I2C2.SDA/SP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); also elsewhere on the board
/PA8: U16.9 (PA08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/SP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); also elsewhere on the board
/PA9: U16.8 (PA09/GPTMR0.CAPT1/UART2.RXD/I2C0.SDA/SP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); also elsewhere on the board
/PA10: U16.7 (PA10/GPTMR0.COMP2/UART2.DE/UART2.RTS/SP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); also elsewhere on the board
/PA11: U16.6 (PA11/UART2.CTS/SPI0.CS0/XPI0.CA_CS1/PWM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); also elsewhere on the board
/PA12: U16.4 (PA12/UART3.CTS/I2C1.SDA/SPI0.MISO/PWM1.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); also elsewhere on the board
/PA13: U16.3 (PA13/GPTMR1.COMP3/UART3.DE/UART3.RTS/I2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); also elsewhere on the board
/PA14: U16.2 (PA14/UART3.RXD/SPI0.DAT2/MCAN1.RXD/PWM1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); also elsewhere on the board
/PA15: U16.1 (PA15/GPTMR0.COMP3/UART3.TXD/SPI0.DAT3/M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); also elsewhere on the board
/PA16: U16.21 (PA16/GPTMR3.COMP0/PWM2.P0/TRGM.P16/RDC0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); also elsewhere on the board
/PA17: U16.20 (PA17/GPTMR3.CAPT0/PWM2.P1/TRGM.P17/RDC0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); also elsewhere on the board
/PA18: U16.19 (PA18/GPTMR3.COMP1/I2C2.SCL/PWM2.P2/TRGM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); also elsewhere on the board
/PA19: U16.18 (PA19/GPTMR3.CAPT1/I2C2.SDA/MCAN0.STBY/P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); also elsewhere on the board
GND: C101.2, C102.2, U26.3 (GND), U26.8 (GND); also elsewhere on the board

Parts:
C105: 100nF,50V; C_0603_1608Metric
U16: HPM6P41IPB1; LQFP-100_14x14mm_P0.5mm_EP5.0x5.0mm

Connections:
+3.3V: C105.1, U16.55 (VIO_B02); also elsewhere on the board
/PD2: U16.64 (PD02/GPTMR1.COMP1/I2C2.SCL/SPI2.MOSI/TR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)
/PD3: U16.63 (PD03/GPTMR1.CAPT1/I2C2.SDA/SPI2.DAT2/MC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)
/PD4: U16.62 (PD04/UART1.CTS/SPI2.DAT3/MCAN0.RXD/TRGM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)
/PD6: U16.60 (PD06/GPTMR0.CAPT0/UART1.RXD/SPI2.CS2/TR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); also elsewhere on the board
/PD8: U16.58 (PD08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/SP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); also elsewhere on the board
/PD16: U16.54 (PD16/GPTMR3.COMP0/PWM2.P0/TRGM.P16/ETH0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)
/PD17: U16.53 (PD17/GPTMR3.CAPT0/PWM2.P1/TRGM.P17/ETH0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)
/PD18: U16.52 (PD18/GPTMR3.COMP1/I2C2.SCL/PWM2.P2/TRGM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)
/PD19: U16.51 (PD19/GPTMR3.CAPT1/I2C2.SDA/MCAN0.STBY/P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)
/PD20: U16.49 (PD20/MCAN0.RXD/PWM2.P4/TRGM.P20/ETH0.TX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); also elsewhere on the board
/PD21: U16.48 (PD21/GPTMR3.COMP2/MCAN0.TXD/PWM2.P5/TRG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); also elsewhere on the board
/PD22: U16.47 (PD22/GPTMR2.CAPT0/PWM2.P6/TRGM.P22/QEI1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); also elsewhere on the board
/PD23: U16.46 (PD23/GPTMR2.COMP0/PWM2.P7/TRGM.P23/QEI1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); also elsewhere on the board
/PD24: U16.45 (PD24/GPTMR2.COMP1/I2C0.SCL/PWM0.P0/TRGM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); also elsewhere on the board
/PD25: U16.44 (PD25/GPTMR2.CAPT1/I2C0.SDA/PWM0.P1/TRGM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); also elsewhere on the board
/PD26: U16.43 (PD26/GPTMR2.COMP2/SPI1.SCLK/PWM0.P2/TRG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); also elsewhere on the board
/PD27: U16.42 (PD27/SPI1.CS0/PWM0.P3/TRGM.P27/QEI1.A/Q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); also elsewhere on the board
GND: C105.2; also elsewhere on the board
USB_DN: U16.65 (PD01/GPTMR1.CAPT0/SPI2.MISO/TRGM.P01/ET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); also elsewhere on the board
USB_DP: U16.66 (PD00/GPTMR1.COMP0/SPI2.SCLK/TRGM.P00/ET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); also elsewhere on the board

Parts:
C52, C54, C56, C57, C60, C62, C64, C65, C67, C68, C69, C70: 100nF,50V; C_0603_1608Metric
C53, C55: 6pF; C_0603_1608Metric
C61, C66: 4.7uF,10V; C_0603_1608Metric
C63: SCC1808X102K502TS; C_1808_4520Metric; Tolerance 10 %; MPN SCC1808X102K502TS
C71, C72, C73, C74: 47pF,50V; C_0603_1608Metric
D16, D17: NUP2105L; SOT-23
J5, J6: SMA; SMA_Amphenol_901-144_Vertical
J7, J8: Conn_01x03; PhoenixContact_MC_1,5_3-G-3.81_1x03_P3.81mm_Horizontal
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L6, L7: ACT45B-510-2P-TL003; SDCW2012-2-900TF
R49, R50: 5.1kΩ; R_0603_1608Metric
R51: 10Ω; R_0603_1608Metric
R52, R53, R54, R55: 50Ω; R_0603_1608Metric
R56, R57: 2kΩ; R_0603_1608Metric
R58, R61, R62: 5.1k; R_0603_1608Metric
R59, R60: 1kΩ; R_0603_1608Metric
R63: 10kΩ; R_0603_1608Metric
R64, R65: 120Ω; R_1206_3216Metric
SW1: 焊盘; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W8.61mm_P2.54mm_LowProfile
SW2, SW3, SW4: Push_Button; LCSC_SW_SPST_PTS810
U14: AT24C08C-SSHM-T; SOIC-8_3.9x4.9mm_P1.27mm
U15: TMP112xxDRL; SOT-563
U16: HPM6P41IPB1; LQFP-100_14x14mm_P0.5mm_EP5.0x5.0mm
U19: CA-IS3762HN; Mpn CA-IS3762HN
U20: TME-0505S; BXXXXS-1W隔离电源
U21: SIT3088ETK; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U22: TJA1044GTK/3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
Y1: 24MHz ±10ppm 6pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C52.2, C56.1, C57.2, C62.2, R49.2, R50.2, R56.2, R57.2, R58.1, R61.1, R62.1, SW1.1 (PIN1), SW1.2 (PIN2), U14.8 (VCC), U15.5 (V+), U16.67 (VPLLVUSB), U19.1 (VDDA); also elsewhere on the board
+5V: C61.1, R51.2, U20.2 (+Vin); also elsewhere on the board
+5VC: C65.2, C66.1, C68.2, C69.2, C70.2, U19.16 (VDDB), U20.4 (+Vout), U21.8 (VCC), U22.3 (VCC), U22.5 (VIO)
/MCU_MISC/485_DE_ISO: R63.2, U19.13 (VO3), U21.2 (~RE), U21.3 (DE)
/MCU_MISC/485_RX_ISO: U19.10 (VI6), U21.1 (RO)
/MCU_MISC/485_TX_ISO: U19.12 (VO4), U21.4 (DI)
/MCU_MISC/CAN_RXD_ISO: U19.11 (VI5), U22.4 (RXD)
/MCU_MISC/CAN_STBY_ISO: U19.14 (VO2), U22.8 (STB)
/MCU_MISC/CAN_TXD_ISO: U19.15 (VO1), U22.1 (TXD)
/MCU_MISC/RESETN: C60.2, R58.2, SW2.2, U16.29 (RESET)
/MCU_MISC/WAKEUP: U16.30 (WAKEUP)
/MCU_MISC/XTALI: C53.1, U16.71 (XTALI), Y1.3
/MCU_MISC/XTALO: C55.1, U16.70 (XTALO), Y1.1
/PA2: R59.2; also elsewhere on the board
/PA3: R60.2; also elsewhere on the board
/PA8: U19.3 (VI2); also elsewhere on the board
/PA9: U19.6 (VO5); also elsewhere on the board
/PA10: U19.2 (VI1); also elsewhere on the board
/PB0: R55.2; also elsewhere on the board
/PB1: R54.2; also elsewhere on the board
/PB14: U19.7 (VO6); also elsewhere on the board
/PB15: U19.4 (VI3); also elsewhere on the board
/PC13: U19.5 (VI4); also elsewhere on the board
/PD20: C67.2, R62.2, SW4.2; also elsewhere on the board
/PD21: C64.2, R61.2, SW3.2; also elsewhere on the board
/PD22: R49.1, U14.7 (WP); also elsewhere on the board
/PD23: R50.1, U15.3 (ALERT); also elsewhere on the board
/PD24: R56.1, U14.6 (SCL), U15.1 (SCL); also elsewhere on the board
/PD25: R57.1, U14.5 (SDA), U15.6 (SDA); also elsewhere on the board
GND: C52.1, C53.2, C54.2, C55.2, C56.2, C57.1, C60.1, C61.2, C62.1, C63.2, C64.1, C67.1, J5.2 (Ext), J6.2 (Ext), R52.1, R53.1, SW2.1, SW3.1, SW4.1, U14.2 (A1), U14.3 (A2), U14.4 (GND), U15.2 (GND), U15.4 (ADD0), U19.8 (GNDA), U20.1 (-Vin), Y1.2, Y1.4; also elsewhere on the board
ISO_GNDC: C63.1, C65.1, C66.2, C68.1, C69.1, C70.1, C71.1, C72.2, C73.1, C74.2, D16.3 (A), D17.3 (A), J7.2, J8.2, R63.1, U19.9 (GNDB), U20.3 (-Vout), U21.5 (GND), U21.9 (EP), U22.2 (GND), U22.9 (EP)
unnamed 124: J5.1 (In), R52.2, R54.1; also elsewhere on the board
unnamed 125: J6.1 (In), R53.2, R55.1; also elsewhere on the board
unnamed: C71.2, D16.2 (K), J7.1, JP2.1 (A), L7.3
unnamed: C72.1, D16.1 (K), J7.3, L7.4, R65.1
unnamed: C74.1, D17.1 (K), J8.1, L6.3, R64.1
unnamed: C73.2, D17.2 (K), J8.3, JP1.1 (A), L6.4
unnamed: JP1.2 (B), R64.2
unnamed: JP2.2 (B), R65.2
unnamed: R59.1, SW1.3 (PIN3)
unnamed: R60.1, SW1.4 (PIN4)
unnamed: C54.1, R51.1, U16.69 (VBUS)
unnamed: L6.1, U21.6 (A)
unnamed: L6.2, U21.7 (B)
unnamed: L7.2, U22.7 (CANH)
unnamed: L7.1, U22.6 (CANL)

Notes on the sheet:
EEPROM TRGM 温度计
ADDR:0x48
ADDR:0xA0~A7
485
CAN
晶振 复位 VBUS BOOT 按键

Parts:
BZ1: Buzzer_DummyPIn3; Buzzer_5020_MetalHole
C75: 1uF; C_0603_1608Metric
C76, C80, C81, C82: 100nF,50V; C_0603_1608Metric
C77, C79: 1uF,10V; C_0603_1608Metric
C78: SCC1808X102K502TS; C_1808_4520Metric; Tolerance 10 %; MPN SCC1808X102K502TS
D18, D19, D20: LED; LED_0603_1608Metric
J9: USB_C_Receptacle_USB2.0_16P; USB_C_16P_On_Board
J10, J12, J13: 排针; PinHeader_1x02_P2.54mm_Vertical
J11: Conn_ARM_JTAG_SWD_20; IDC-Header_2x10_P2.54mm_Vertical
Q5, Q6: AO3400A; SOT-23
R66: 0Ω; R_0603_1608Metric
R67, R68: 5.1kΩ; R_0603_1608Metric
R69, R70, R71, R72, R73, R74: 10K; R_0603_1608Metric
R75, R76, R77: 10k; R_0603_1608Metric
S1: 焊接式_TFT_1.14_135X240_13PIN; JLC_3DModel_Q 2f6c02c867a549178f5564592e40b008
U23: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm
U24: XC6206PxxxMR; SOT-23-3
U25: CA-IS3762HN; Mpn CA-IS3762HN

Connections:
+3.3V: C80.2, C81.1, C82.1, D18.2 (A), D19.2 (A), D20.2 (A), R72.1, R73.1, S1.10 (VCC), S1.12 (VCC), U25.16 (VDDB); also elsewhere on the board
+5V: J10.1, R66.1; also elsewhere on the board
/J_TCK: R74.2, U25.14 (VO2); also elsewhere on the board
/J_TDI: R73.2, U25.13 (VO3); also elsewhere on the board
/J_TDO: U25.11 (VI5); also elsewhere on the board
/J_TMS: R72.2, U25.15 (VO1); also elsewhere on the board
/MCU_MISC2/5V_SUPPLY: C77.1, J11.19 (DBGACK/NC), J12.1, U24.3 (VI)
/MCU_MISC2/CON_RX: J13.1, U25.5 (VI4)
/MCU_MISC2/CON_TCK: J11.9 (TCK/SWDCLK), R69.2, U25.3 (VI2)
/MCU_MISC2/CON_TDI: J11.5 (TDI), R71.2, U25.4 (VI3)
/MCU_MISC2/CON_TDO: J11.13 (TDO/SWO), U25.6 (VO5)
/MCU_MISC2/CON_TMS: J11.7 (TMS/SWDIO), R70.2, U25.2 (VI1)
/MCU_MISC2/CON_TX: J13.2, U25.7 (VO6)
/PA0: U25.10 (VI6); also elsewhere on the board
/PA1: U25.12 (VO4); also elsewhere on the board
/PA11: Q6.1 (G); also elsewhere on the board
/PB3: S1.7 (CS); also elsewhere on the board
/PB4: S1.4 (SCL); also elsewhere on the board
/PB13: S1.3 (SDA); also elsewhere on the board
/PD26: S1.6 (RES); also elsewhere on the board
/PD27: S1.5 (DC); also elsewhere on the board
/PY0: R75.1; also elsewhere on the board
/PY1: R76.1; also elsewhere on the board
/PY2: R77.1; also elsewhere on the board
/PY3: Q5.1 (G); also elsewhere on the board
GND: BZ1.3 (DUM), C75.2, C78.1, C80.1, C81.2, C82.2, J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.S1 (SHIELD), Q5.2 (S), Q6.2 (S), R67.2, R68.2, R74.1, S1.8 (GND), S1.13 (GND), U23.3 (GND), U23.8 (GND), U25.9 (GNDB); also elsewhere on the board
ISO_GND: C76.1, C77.2, C78.2, C79.2, J11.4 (GND), J11.6 (GND), J11.8 (GND), J11.10 (GND), J11.12 (GND), J11.14 (GND), J11.16 (GND), J11.18 (GND), J11.20 (GND), J12.2, R69.1, U24.1 (GND), U25.8 (GNDA)
unnamed 103: BZ1.1 (+), C75.1, R66.2; also elsewhere on the board
unnamed 104: BZ1.2 (-), Q5.3 (D); also elsewhere on the board
unnamed: D18.1 (K), R75.2
unnamed: D19.1 (K), R76.2
unnamed: D20.1 (K), R77.2
unnamed: J9.A5 (CC1), R67.1
unnamed: J9.B5 (CC2), R68.1
unnamed: Q6.3 (D), S1.11 (LEDK)
USB_DN: J9.A7 (D-), J9.B7 (D-), U23.1 (D1+), U23.10 (NC); also elsewhere on the board
USB_DP: J9.A6 (D+), J9.B6 (D+), U23.2 (D1-), U23.9 (NC); also elsewhere on the board
VTREF: C76.2, C79.1, J11.1 (VTREF), R70.1, R71.1, U24.2 (VO), U25.1 (VDDA)

Notes on the sheet:
IO LED
USB
蜂鸣器
